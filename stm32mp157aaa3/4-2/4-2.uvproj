# Keil uVision project 4-2.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: 4-2
  group Source Group 1
    ./: 42s.s 42c.c
