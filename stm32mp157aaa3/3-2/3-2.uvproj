# Keil uVision project 3-2.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: 3-2
  group Source Group 1
    ./: 3-2.s
