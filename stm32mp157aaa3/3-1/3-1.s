.IF 0
	MOV r2,#2
	MOV R3,#0XFFFFFFFF
	UMULL R0,R1,R2,R3
	UMLAL R0,R1,R2,R3
	NOP
	NOP
.ENDIF
	
.IF 0
	MOV R0,#0X1
	MOV R1,#0X2
	B MDADD
LOOP:
	BL LOOP
MDADD:
	ADD R2,R0,R1;
	MOV PC,LR
.ENDIF

.IF 0
	@LDR R2,=0X12345673
	LDR R9,=VAR1
	LDR R0,[R9]
	ADD R0,R0,#0X1
	STR R0,[R9]
	LDR R1,[R9]
	NOP
	NOP
.data
	VAR1: .WORD 0X12345678
.ENDIF

.IF 0
	LDR R0,=ARR1
	LDR R2,=ARR2
COPY:
	LDRB R1,[R0],#1
	STRB R1,[R2],#1
	CMP R1,#0
	BNE COPY
	NOP
	NOP
.data
	ARR1: .STRING "1234567\0"
	ARR2: .SPACE 8
.ENDIF
	
.IF 1
	LDR R0,=ARR1
	LDR R1,=ARR2
	LDMIA R0!,{R3-R4}
	STMIA R1!,{R3-R4}
	NOP
	NOP
.data
	ARR1:.BYTE '1','2','3','4','5','6','7','8'
	ARR2: .SPACE 8
.ENDIF

#SUPERV->USER
.IF 0
	MRS R0,CPSR @REG<-STATE
	BIC R0,#0X3
	MSR CPSR,R0 @STATE<-REG
.ENDIF
	