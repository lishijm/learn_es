# Keil uVision project 2-1.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: 2-1
  group Source Group 1
    ./: 2-1.s
